/*
 * SHA-256 / HMAC-SHA256 的宿主测试。
 *
 * 期望摘要全部是 FIPS 180-4 / RFC 4231 里公布的常量，以字节数组硬编码，
 * 不在运行期用被测代码算出来（否则就是自己证明自己）。
 *
 * 覆盖：空串、abc、448 位（56 字节）消息、64 字节消息、100 万字节 'a'、
 * RFC 4231 测试用例 1-7、增量 == 一次性（含逐字节喂）、分块边界扫描、
 * couple_ct_equal 的相等/不等/短缓冲。
 */

#include <stdint.h>
#include <stdio.h>
#include <string.h>

#include "couple_sha256.h"

#define CHECK(cond)                                                           \
    do {                                                                      \
        if (!(cond)) {                                                        \
            fprintf(stderr, "FAIL %s:%d: %s\n", __FILE__, __LINE__, #cond);    \
            return 1;                                                         \
        }                                                                     \
    } while (0)

static void print_hex(const char *label, const uint8_t *buf, size_t len)
{
    size_t i;

    fprintf(stderr, "  %s = ", label);
    for (i = 0; i < len; i++) {
        fprintf(stderr, "%02x", (unsigned)buf[i]);
    }
    fputc('\n', stderr);
}

static int report_mismatch(const char *label, const uint8_t *got, const uint8_t *want, size_t len)
{
    fprintf(stderr, "FAIL: digest mismatch for %s\n", label);
    print_hex("got ", got, len);
    print_hex("want", want, len);
    return 0;
}

/* ---------- FIPS 180-4 / NIST 向量 ---------- */

/* "abc" */
static const uint8_t k_sha_abc[32] = {
    0xba, 0x78, 0x16, 0xbf, 0x8f, 0x01, 0xcf, 0xea, 0x41, 0x41, 0x40, 0xde, 0x5d, 0xae, 0x22, 0x23,
    0xb0, 0x03, 0x61, 0xa3, 0x96, 0x17, 0x7a, 0x9c, 0xb4, 0x10, 0xff, 0x61, 0xf2, 0x00, 0x15, 0xad,
};

/* 448 位消息："abcdbcdecdefdefgefghfghighijhijkijkljklmklmnlmnomnopnopq"（56 字节，
 * 正好压在填充边界上）。 */
static const uint8_t k_sha_448bit[32] = {
    0x24, 0x8d, 0x6a, 0x61, 0xd2, 0x06, 0x38, 0xb8, 0xe5, 0xc0, 0x26, 0x93, 0x0c, 0x3e, 0x60, 0x39,
    0xa3, 0x3c, 0xe4, 0x59, 0x64, 0xff, 0x21, 0x67, 0xf6, 0xec, 0xed, 0xd4, 0x19, 0xdb, 0x06, 0xc1,
};

/* 100 万字节 'a'。 */
static const uint8_t k_sha_million_a[32] = {
    0xcd, 0xc7, 0x6e, 0x5c, 0x99, 0x14, 0xfb, 0x92, 0x81, 0xa1, 0xc7, 0xe2, 0x84, 0xd7, 0x3e, 0x67,
    0xf1, 0x80, 0x9a, 0x48, 0xa4, 0x97, 0x20, 0x0e, 0x04, 0x6d, 0x39, 0xcc, 0xc7, 0x11, 0x2c, 0xd0,
};

/* 空串。 */
static const uint8_t k_sha_empty[32] = {
    0xe3, 0xb0, 0xc4, 0x42, 0x98, 0xfc, 0x1c, 0x14, 0x9a, 0xfb, 0xf4, 0xc8, 0x99, 0x6f, 0xb9, 0x24,
    0x27, 0xae, 0x41, 0xe4, 0x64, 0x9b, 0x93, 0x4c, 0xa4, 0x95, 0x99, 0x1b, 0x78, 0x52, 0xb8, 0x55,
};

/* 64 字节消息（正好整块，填充要另开一块）：NIST 896 位消息的前 64 字节。
 * 摘要由独立实现（Python hashlib / OpenSSL）算出后硬编码。 */
static const char k_msg_64[] =
    "abcdefghbcdefghicdefghijdefghijkefghijklfghijklmghijklmnhijklmno";
static const uint8_t k_sha_64byte[32] = {
    0x2f, 0xf1, 0x00, 0xb3, 0x6c, 0x38, 0x6c, 0x65, 0xa1, 0xaf, 0xc4, 0x62, 0xad, 0x53, 0xe2, 0x54,
    0x79, 0xbe, 0xc9, 0x49, 0x8e, 0xd0, 0x0a, 0xa5, 0xa0, 0x4d, 0xe5, 0x84, 0xbc, 0x25, 0x30, 0x1b,
};

/* ---------- RFC 4231 ---------- */

static const uint8_t k_tc1_key[20] = {0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b,
                                      0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b};
static const char k_tc1_data[] = "Hi There";
static const uint8_t k_tc1_mac[32] = {
    0xb0, 0x34, 0x4c, 0x61, 0xd8, 0xdb, 0x38, 0x53, 0x5c, 0xa8, 0xaf, 0xce, 0xaf, 0x0b, 0xf1, 0x2b,
    0x88, 0x1d, 0xc2, 0x00, 0xc9, 0x83, 0x3d, 0xa7, 0x26, 0xe9, 0x37, 0x6c, 0x2e, 0x32, 0xcf, 0xf7,
};

static const char k_tc2_key[] = "Jefe";
static const char k_tc2_data[] = "what do ya want for nothing?";
static const uint8_t k_tc2_mac[32] = {
    0x5b, 0xdc, 0xc1, 0x46, 0xbf, 0x60, 0x75, 0x4e, 0x6a, 0x04, 0x24, 0x26, 0x08, 0x95, 0x75, 0xc7,
    0x5a, 0x00, 0x3f, 0x08, 0x9d, 0x27, 0x39, 0x83, 0x9d, 0xec, 0x58, 0xb9, 0x64, 0xec, 0x38, 0x43,
};

static const uint8_t k_tc3_key[20] = {0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa,
                                      0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa};
static const uint8_t k_tc3_data[50] = {
    0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd,
    0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd,
    0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd,
    0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd, 0xdd,
};
static const uint8_t k_tc3_mac[32] = {
    0x77, 0x3e, 0xa9, 0x1e, 0x36, 0x80, 0x0e, 0x46, 0x85, 0x4d, 0xb8, 0xeb, 0xd0, 0x91, 0x81, 0xa7,
    0x29, 0x59, 0x09, 0x8b, 0x3e, 0xf8, 0xc1, 0x22, 0xd9, 0x63, 0x55, 0x14, 0xce, 0xd5, 0x65, 0xfe,
};

static const uint8_t k_tc4_key[25] = {0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09,
                                      0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12,
                                      0x13, 0x14, 0x15, 0x16, 0x17, 0x18, 0x19};
static const uint8_t k_tc4_data[50] = {
    0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd,
    0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd,
    0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd,
    0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd, 0xcd,
};
static const uint8_t k_tc4_mac[32] = {
    0x82, 0x55, 0x8a, 0x38, 0x9a, 0x44, 0x3c, 0x0e, 0xa4, 0xcc, 0x81, 0x98, 0x99, 0xf2, 0x08, 0x3a,
    0x85, 0xf0, 0xfa, 0xa3, 0xe5, 0x78, 0xf8, 0x07, 0x7a, 0x2e, 0x3f, 0xf4, 0x67, 0x29, 0x66, 0x5b,
};

static const uint8_t k_tc5_key[20] = {0x0c, 0x0c, 0x0c, 0x0c, 0x0c, 0x0c, 0x0c, 0x0c, 0x0c, 0x0c,
                                      0x0c, 0x0c, 0x0c, 0x0c, 0x0c, 0x0c, 0x0c, 0x0c, 0x0c, 0x0c};
static const char k_tc5_data[] = "Test With Truncation";
/* RFC 4231 只公布前 16 字节 a3b6167473100ee06e0c796c2955552b，这里硬编码完整 32 字节。 */
static const uint8_t k_tc5_mac[32] = {
    0xa3, 0xb6, 0x16, 0x74, 0x73, 0x10, 0x0e, 0xe0, 0x6e, 0x0c, 0x79, 0x6c, 0x29, 0x55, 0x55, 0x2b,
    0xfa, 0x6f, 0x7c, 0x0a, 0x6a, 0x8a, 0xef, 0x8b, 0x93, 0xf8, 0x60, 0xaa, 0xb0, 0xcd, 0x20, 0xc5,
};

/* 用例 6/7：key 是 131 字节的 0xaa，超过分块长度，先被哈希。 */
static const uint8_t k_tc67_key[131] = {
    0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa,
    0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa,
    0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa,
    0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa,
    0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa,
    0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa,
    0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa,
    0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa,
    0xaa, 0xaa, 0xaa,
};
static const char k_tc6_data[] = "Test Using Larger Than Block-Size Key - Hash Key First";
static const uint8_t k_tc6_mac[32] = {
    0x60, 0xe4, 0x31, 0x59, 0x1e, 0xe0, 0xb6, 0x7f, 0x0d, 0x8a, 0x26, 0xaa, 0xcb, 0xf5, 0xb7, 0x7f,
    0x8e, 0x0b, 0xc6, 0x21, 0x37, 0x28, 0xc5, 0x14, 0x05, 0x46, 0x04, 0x0f, 0x0e, 0xe3, 0x7f, 0x54,
};

static const char k_tc7_data[] =
    "This is a test using a larger than block-size key and a larger than block-size data. "
    "The key needs to be hashed before being used by the HMAC algorithm.";
static const uint8_t k_tc7_mac[32] = {
    0x9b, 0x09, 0xff, 0xa7, 0x1b, 0x94, 0x2f, 0xcb, 0x27, 0x63, 0x5f, 0xbc, 0xd5, 0xb0, 0xe9, 0x44,
    0xbf, 0xdc, 0x63, 0x64, 0x4f, 0x07, 0x13, 0x93, 0x8a, 0x7f, 0x51, 0x53, 0x5c, 0x3a, 0x35, 0xe2,
};

/* ---------- helpers ---------- */

/* 一次性、单次 incrementel、逐字节 incremental 三条路径必须给出同一摘要。 */
static int check_sha256(const char *label, const uint8_t *msg, size_t len, const uint8_t *want)
{
    couple_sha256_t ctx;
    uint8_t out[32];
    size_t i;

    couple_sha256(msg, len, out);
    if (memcmp(out, want, 32) != 0) {
        return report_mismatch(label, out, want, 32);
    }

    couple_sha256_init(&ctx);
    couple_sha256_update(&ctx, msg, len);
    couple_sha256_final(&ctx, out);
    if (memcmp(out, want, 32) != 0) {
        return report_mismatch(label, out, want, 32);
    }

    couple_sha256_init(&ctx);
    for (i = 0; i < len; i++) {
        couple_sha256_update(&ctx, msg + i, 1u);
    }
    couple_sha256_final(&ctx, out);
    if (memcmp(out, want, 32) != 0) {
        return report_mismatch(label, out, want, 32);
    }
    return 1;
}

static int check_hmac(const char *label, const uint8_t *key, size_t key_len, const uint8_t *msg,
                      size_t msg_len, const uint8_t *want)
{
    uint8_t out[32];

    couple_hmac_sha256(key, key_len, msg, msg_len, out);
    if (memcmp(out, want, 32) != 0) {
        return report_mismatch(label, out, want, 32);
    }
    return 1;
}

/* 任意分块写入都必须与一次性结果一致（扫 55/56/64/119/120 这些填充边界）。 */
static int check_chunked(const uint8_t *msg, size_t len, const uint8_t *want)
{
    const size_t chunks[] = {1u, 2u, 3u, 7u, 13u, 31u, 55u, 56u, 63u, 64u, 65u, 119u, 120u, 128u};
    couple_sha256_t ctx;
    uint8_t out[32];
    size_t chunk;
    size_t off;
    size_t step;

    for (step = 0; step < (sizeof(chunks) / sizeof(chunks[0])); step++) {
        chunk = chunks[step];
        if (chunk == 0u || chunk > len) {
            continue;
        }
        couple_sha256_init(&ctx);
        for (off = 0; off < len;) {
            size_t take = (len - off < chunk) ? (len - off) : chunk;
            couple_sha256_update(&ctx, msg + off, take);
            off += take;
        }
        couple_sha256_final(&ctx, out);
        if (memcmp(out, want, 32) != 0) {
            fprintf(stderr, "FAIL: chunked (%u) mismatch\n", (unsigned)chunk);
            print_hex("got ", out, 32);
            print_hex("want", want, 32);
            return 0;
        }
    }
    return 1;
}

int main(void)
{
    static uint8_t million_a[1000000];
    static const uint8_t boundary_lens[] = {55u, 56u, 57u, 63u, 64u, 65u, 119u, 120u, 121u, 128u};
    uint8_t boundary[128];
    uint8_t oneshot[32];
    uint8_t key[200];
    uint8_t a[32];
    uint8_t b[32];
    size_t i;

    /* ---- SHA-256 已知答案（一次性 / 单次 incremental / 逐字节 incremental） ---- */
    CHECK(check_sha256("empty", (const uint8_t *)"", 0u, k_sha_empty));
    CHECK(check_sha256("abc", (const uint8_t *)"abc", 3u, k_sha_abc));
    CHECK(check_sha256("448bit(56B)",
                       (const uint8_t *)"abcdbcdecdefdefgefghfghighijhijkijkljklmklmnlmnomnopnopq",
                       56u, k_sha_448bit));
    CHECK(check_sha256("64byte", (const uint8_t *)k_msg_64, 64u, k_sha_64byte));

    memset(million_a, 'a', sizeof(million_a));
    CHECK(check_sha256("million a", million_a, sizeof(million_a), k_sha_million_a));

    /* ---- 填充边界：55/56/57、63/64/65、119/120/121 字节，任意分块都一致 ---- */
    for (i = 0; i < sizeof(boundary); i++) {
        boundary[i] = (uint8_t)('A' + (i % 26u));
    }
    for (i = 0; i < sizeof(boundary_lens); i++) {
        const size_t n = boundary_lens[i];
        couple_sha256(boundary, n, oneshot);
        if (!check_chunked(boundary, n, oneshot)) {
            fprintf(stderr, "FAIL: boundary length %u\n", (unsigned)n);
            return 1;
        }
    }

    /* ---- HMAC-SHA256：RFC 4231 测试用例 1-7 ---- */
    CHECK(check_hmac("rfc4231 tc1", k_tc1_key, sizeof(k_tc1_key), (const uint8_t *)k_tc1_data,
                     strlen(k_tc1_data), k_tc1_mac));
    CHECK(check_hmac("rfc4231 tc2", (const uint8_t *)k_tc2_key, strlen(k_tc2_key),
                     (const uint8_t *)k_tc2_data, strlen(k_tc2_data), k_tc2_mac));
    CHECK(check_hmac("rfc4231 tc3", k_tc3_key, sizeof(k_tc3_key), k_tc3_data, sizeof(k_tc3_data),
                     k_tc3_mac));
    CHECK(check_hmac("rfc4231 tc4", k_tc4_key, sizeof(k_tc4_key), k_tc4_data, sizeof(k_tc4_data),
                     k_tc4_mac));
    CHECK(check_hmac("rfc4231 tc5", k_tc5_key, sizeof(k_tc5_key), (const uint8_t *)k_tc5_data,
                     strlen(k_tc5_data), k_tc5_mac));
    CHECK(check_hmac("rfc4231 tc6", k_tc67_key, sizeof(k_tc67_key), (const uint8_t *)k_tc6_data,
                     strlen(k_tc6_data), k_tc6_mac));
    CHECK(check_hmac("rfc4231 tc7", k_tc67_key, sizeof(k_tc67_key), (const uint8_t *)k_tc7_data,
                     strlen(k_tc7_data), k_tc7_mac));

    /* 空 key / 空数据也要给出确定结果，不能崩。 */
    memset(key, 0, sizeof(key));
    couple_hmac_sha256(key, 0u, NULL, 0u, oneshot);
    couple_hmac_sha256(NULL, 0u, "", 0u, b);
    CHECK(memcmp(oneshot, b, 32) == 0);

    /* ---- couple_ct_equal ---- */
    for (i = 0; i < sizeof(a); i++) {
        a[i] = (uint8_t)(i * 7u + 3u);
        b[i] = a[i];
    }
    CHECK(couple_ct_equal(a, b, sizeof(a)));
    b[sizeof(b) - 1u] ^= 0x01u;
    CHECK(!couple_ct_equal(a, b, sizeof(a)));
    b[sizeof(b) - 1u] ^= 0x01u;
    b[0] ^= 0x80u;
    CHECK(!couple_ct_equal(a, b, sizeof(a)));
    b[0] ^= 0x80u;

    /* 短缓冲：只比前 1 字节也应能区分。 */
    CHECK(couple_ct_equal(a, b, 1u));
    a[0] ^= 0xffu;
    CHECK(!couple_ct_equal(a, b, 1u));
    CHECK(couple_ct_equal(a, b, 0u)); /* len == 0，没有字节参与比较 */
    a[0] ^= 0xffu;
    CHECK(couple_ct_equal(a, b, sizeof(a)));

    /* 长度不等只能靠指针非法表达：空指针一律 false（fail closed）。 */
    CHECK(!couple_ct_equal(NULL, b, 32u));
    CHECK(!couple_ct_equal(a, NULL, 32u));
    CHECK(!couple_ct_equal(NULL, NULL, 0u));

    puts("couple_sha256 tests: PASS");
    return 0;
}